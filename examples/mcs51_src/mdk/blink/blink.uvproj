# Keil uVision project blink.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: blink +hex
  c flags: Optimize=8 SizeSpeed=1
  group asm
    ./: STARTUP.A51
  group app
    ./Sources/app/: main.c
