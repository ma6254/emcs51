# Keil uVision project blink.uvprojx, settings and files
target host_blink (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: host_blink
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Sources\app;..\..\..\..\..\src;..\..\..\..\vendor\SEGGER_RTT_V812c\RTT;..\..\..\..\vendor\SEGGER_RTT_V812c\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./Sources/app/: main.c
  group emcs51
    ../../../../../src/: emcs51.c
    ../../../../../src/core/: emcs51_core.c emcs51_inst.c
  group emcs51_instruction
    ../../../../../src/instruction/: emcs51_general_inst.c
  group emcs51_testing
    ../../../../../testing/: emcs51_testing.c emcs51_nop_inst_test.c emcs51_sjmp_inst_test .c emcs51_mov_direct_immed_inst_test.c
  group segger_rtt
    ../../../../vendor/SEGGER_RTT_V812c/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
